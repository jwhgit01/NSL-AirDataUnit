## src/PX4/Kconfig
```kconfig
menuconfig DRIVERS_NSL_ADU
	bool "nsl_adu"
	default n
	---help---
		Enable support for NSL air data unit
```
